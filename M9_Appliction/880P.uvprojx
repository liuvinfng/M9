# Keil uVision project 880P.uvprojx, settings and files
target 880P_BL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 880P +hex
  AfterMake: C:\keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/bin/880P.bin ./Objects/880P.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4 __FPU_PRESENT=1,MY_D
  c include: .\Library\GD32F30x_standard_peripheral\Include;.\Library\CMSIS\GD\GD32F30x\Include;.\Library\CMSIS;.\INC;.\Device;.\FreeRTOS;.\FreeRTOS\Source;.\FreeRTOS\Source\CMSIS_RTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Tuya
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./SRC/: main.c Charge.c ProjectTask.c UserInterface.c Remote_Mode.c Spot.c Standby.c WallFollow.c HomeStraight.c
    ./: log.txt
  group Navigation
    ./SRC/: CorMove.c PathPlanning.c ShortestPath.c Map.c
  group Tuya
    ./Tuya/: mcu_api.c protocol.c system.c
  group Base
    ./SRC/: SysInitialize.c gd32f30x_it.c Movement.c Display.c USART.c SPI.c Speaker.c Rcon.c RTC.c TouchPad.c Gyro.c Wheel.c Obscliff.c Bldc.c Brush.c WifiOTA.c W25Q16.c MyMath.c Debug.c printf-stdarg.c
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./FreeRTOS/: freertos.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group StdPeriph_Driver
    ./Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c
  group Device
    ./Device/: system_gd32f30x.c startup_gd32f30x_hd.s
  group Include
    ./INC/: Bldc.h Brush.h Charge.h config.h CorMove.h Debug.h Display.h gd32f30x_it.h gd32f30x_libopt.h Gyro.h Home.h HomeStraight.h HomeWall.h main.h Map.h Movement.h MyMath.h Obscliff.h PathPlanning.h ProjectTask.h Rcon.h Remote_Mode.h RTC.h ShortestPath.h Speaker.h SPI.h Spot.h Standby.h SysInitialize.h TouchPad.h USART.h Usart_IAP.h UserInterface.h WallFollow.h Wheel.h
